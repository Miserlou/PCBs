.title KiCad schematic
U1 Net-_C1-Pad1_ Net-_R1-Pad2_ Net-_C2-Pad1_ Net-_R2-Pad2_ Net-_C10-Pad2_ Net-_C3-Pad1_ 40106
U3 Net-_R10-Pad1_ Net-_R12-Pad2_ Net-_Q1-Pad2_ Net-_C10-Pad2_ Net-_C3-Pad1_ 4070
SW2 Net-_R1-Pad1_ Net-_R4-Pad2_ Net-_J2-Pad1_ SW_SPDT
SW1 Net-_R2-Pad1_ Net-_R3-Pad2_ Net-_J3-Pad1_ SW_SPDT
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad2_ Net-_C3-Pad1_ 2N3904
RV1 NC_01 Net-_R1-Pad1_ Net-_C1-Pad1_ YOUNGPRIEST_100K
C1 Net-_C1-Pad1_ GND C
C2 Net-_C2-Pad1_ GND C
R1 Net-_R1-Pad1_ Net-_R1-Pad2_ 1K
R2 Net-_R2-Pad1_ Net-_R2-Pad2_ 1K
J2 Net-_J2-Pad1_ GND Input_1
J3 Net-_J3-Pad1_ GND Input_2
J4 Net-_J4-Pad1_ GND Output_1
RV2 NC_02 Net-_R2-Pad1_ Net-_C2-Pad1_ OLDPRIEST 100K
R4 Net-_R4-Pad1_ Net-_R4-Pad2_ 10K
R6 Net-_R4-Pad1_ GND 100K
U2 Net-_R10-Pad2_ Net-_R7-Pad2_ Net-_R4-Pad1_ Net-_C10-Pad2_ Net-_R3-Pad1_ Net-_R7-Pad2_ Net-_R9-Pad2_ Net-_C3-Pad1_ TL072
R7 Net-_C3-Pad1_ Net-_R7-Pad2_ 100K
R3 Net-_R3-Pad1_ Net-_R3-Pad2_ 10K
R5 Net-_R3-Pad1_ GND 100K
R10 Net-_R10-Pad1_ Net-_R10-Pad2_ 100K
R9 Net-_R12-Pad2_ Net-_R9-Pad2_ 100K
R11 Net-_C3-Pad1_ Net-_R10-Pad1_ 100K
R12 Net-_C3-Pad1_ Net-_R12-Pad2_ 100K
R8 Net-_R7-Pad2_ GND 15K - XXX VR??
R13 Net-_Q1-Pad1_ Net-_D3-Pad2_ 1K (LED)
R14 Net-_Q1-Pad1_ Net-_J4-Pad1_ 1K8
R15 Net-_J4-Pad1_ GND 1K
D3 GND Net-_D3-Pad2_ LED
J1 Net-_D2-Pad1_ Net-_D2-Pad1_ Net-_C3-Pad2_ Net-_C3-Pad2_ Net-_C3-Pad2_ Net-_C3-Pad2_ Net-_C3-Pad2_ Net-_C3-Pad2_ Net-_D1-Pad2_ Net-_D1-Pad2_ Synth_power_2x5
D1 Net-_C3-Pad1_ Net-_D1-Pad2_ 1N4148
D2 Net-_D2-Pad1_ Net-_C10-Pad2_ 1N4148
C3 Net-_C3-Pad1_ Net-_C3-Pad2_ 10uf
C4 Net-_C3-Pad2_ Net-_C10-Pad2_ 10uf
C6 GND Net-_C3-Pad1_ 100nf
C8 GND Net-_C3-Pad1_ 100nf
C9 GND Net-_C3-Pad1_ 100nf
C10 GND Net-_C10-Pad2_ 100nf
C7 GND Net-_C10-Pad2_ 100nf
C5 GND Net-_C10-Pad2_ 100nf
.end
